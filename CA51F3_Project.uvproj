# Keil uVision project CA51F3_Project.uvproj, settings and files
target CA51F (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: project +hex
  c flags: Optimize=9
  c include: .\user_aip3368h;.\user_code;.\driver_on_chip\uart;..\project-2026-08-19-CA51F353P6-SSOP28;.\driver_on_chip\timer0;.\includes;.\driver\aip3368;.\driver\key;.\driver_on_chip\timer1;.\Library\Includes
  link misc: REMOVEUNUSED
  group Start_Up
    ./Library/Lib/: STARTUP.A51
  group driver
    ./driver/aip3368/: aip3368.c aip3368h_display.c
  group driver_on_chip
    ./driver_on_chip/uart/: uart.c
    ./driver_on_chip/timer0/: timer0.c
    ./driver_on_chip/timer1/: timer1.c
  group Lib_Src
    ./: main.c
    ./Library/Sources/: delay.c system_clock.c flash.c ca51f3xsfr.c
  group user_code
    ./user_code/: ui.c user_debug.c engine_speed_scan.c boot_animation.c instrument.c pin_level_scan.c uart_receiver.c key_event_process.c uart_transmitter.c ui_speed_process.c
